# Keil uVision project НАМИ.uvproj, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F051R8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: project +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\inc;.\inc_SYS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK
    C:/Keil_v5/ARM/Startup/ST/STM32F0xx/: startup_stm32f051.s
  group CMSIS
    ./: system_stm32f051.c stm32f0xx_gpio.c stm32f0xx_rcc.c
  group User
    ./: Main.c Timers.c USART.c
  group Text
    ./: Что сделать.c
